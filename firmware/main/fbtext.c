#include "fbtext.h"

#include <ctype.h>

typedef struct {
    char    ch;
    uint8_t col[5];     /* columns, bit 0 = top row */
} glyph_t;

static const glyph_t FONT[] = {
    {' ',  {0x00, 0x00, 0x00, 0x00, 0x00}},
    {'!',  {0x00, 0x00, 0x5F, 0x00, 0x00}},
    {'[',  {0x00, 0x7F, 0x41, 0x41, 0x00}},
    {']',  {0x00, 0x41, 0x41, 0x7F, 0x00}},
    {';',  {0x00, 0x56, 0x36, 0x00, 0x00}},
    {'_',  {0x40, 0x40, 0x40, 0x40, 0x40}},
    {'\'', {0x00, 0x05, 0x03, 0x00, 0x00}},
    {'(',  {0x00, 0x1C, 0x22, 0x41, 0x00}},
    {')',  {0x00, 0x41, 0x22, 0x1C, 0x00}},
    {'%',  {0x23, 0x13, 0x08, 0x64, 0x62}},
    {'+',  {0x08, 0x08, 0x3E, 0x08, 0x08}},
    {',',  {0x00, 0x50, 0x30, 0x00, 0x00}},
    {'-',  {0x08, 0x08, 0x08, 0x08, 0x08}},
    {'.',  {0x00, 0x60, 0x60, 0x00, 0x00}},
    {'/',  {0x20, 0x10, 0x08, 0x04, 0x02}},
    {'0',  {0x3E, 0x51, 0x49, 0x45, 0x3E}},
    {'1',  {0x00, 0x42, 0x7F, 0x40, 0x00}},
    {'2',  {0x42, 0x61, 0x51, 0x49, 0x46}},
    {'3',  {0x21, 0x41, 0x45, 0x4B, 0x31}},
    {'4',  {0x18, 0x14, 0x12, 0x7F, 0x10}},
    {'5',  {0x27, 0x45, 0x45, 0x45, 0x39}},
    {'6',  {0x3C, 0x4A, 0x49, 0x49, 0x30}},
    {'7',  {0x01, 0x71, 0x09, 0x05, 0x03}},
    {'8',  {0x36, 0x49, 0x49, 0x49, 0x36}},
    {'9',  {0x06, 0x49, 0x49, 0x29, 0x1E}},
    {':',  {0x00, 0x36, 0x36, 0x00, 0x00}},
    {'<',  {0x08, 0x14, 0x22, 0x41, 0x00}},
    {'=',  {0x14, 0x14, 0x14, 0x14, 0x14}},
    {'>',  {0x00, 0x41, 0x22, 0x14, 0x08}},
    {'?',  {0x02, 0x01, 0x51, 0x09, 0x06}},
    {'A',  {0x7E, 0x11, 0x11, 0x11, 0x7E}},
    {'B',  {0x7F, 0x49, 0x49, 0x49, 0x36}},
    {'C',  {0x3E, 0x41, 0x41, 0x41, 0x22}},
    {'D',  {0x7F, 0x41, 0x41, 0x22, 0x1C}},
    {'E',  {0x7F, 0x49, 0x49, 0x49, 0x41}},
    {'F',  {0x7F, 0x09, 0x09, 0x09, 0x01}},
    {'G',  {0x3E, 0x41, 0x49, 0x49, 0x7A}},
    {'H',  {0x7F, 0x08, 0x08, 0x08, 0x7F}},
    {'I',  {0x00, 0x41, 0x7F, 0x41, 0x00}},
    {'J',  {0x20, 0x40, 0x41, 0x3F, 0x01}},
    {'K',  {0x7F, 0x08, 0x14, 0x22, 0x41}},
    {'L',  {0x7F, 0x40, 0x40, 0x40, 0x40}},
    {'M',  {0x7F, 0x02, 0x0C, 0x02, 0x7F}},
    {'N',  {0x7F, 0x04, 0x08, 0x10, 0x7F}},
    {'O',  {0x3E, 0x41, 0x41, 0x41, 0x3E}},
    {'P',  {0x7F, 0x09, 0x09, 0x09, 0x06}},
    {'Q',  {0x3E, 0x41, 0x51, 0x21, 0x5E}},
    {'R',  {0x7F, 0x09, 0x19, 0x29, 0x46}},
    {'S',  {0x46, 0x49, 0x49, 0x49, 0x31}},
    {'T',  {0x01, 0x01, 0x7F, 0x01, 0x01}},
    {'U',  {0x3F, 0x40, 0x40, 0x40, 0x3F}},
    {'V',  {0x1F, 0x20, 0x40, 0x20, 0x1F}},
    {'W',  {0x3F, 0x40, 0x38, 0x40, 0x3F}},
    {'X',  {0x63, 0x14, 0x08, 0x14, 0x63}},
    {'Y',  {0x07, 0x08, 0x70, 0x08, 0x07}},
    {'Z',  {0x61, 0x51, 0x49, 0x45, 0x43}},
};

static const glyph_t *find_glyph(char c)
{
    c = (char)toupper((unsigned char)c);
    for (size_t i = 0; i < sizeof FONT / sizeof FONT[0]; i++) {
        if (FONT[i].ch == c) {
            return &FONT[i];
        }
    }
    return NULL;
}

void fb_rect(fb_t *fb, int x, int y, int w, int h, uint16_t color)
{
    if (x < 0) {
        w += x;
        x = 0;
    }
    if (y < 0) {
        h += y;
        y = 0;
    }
    if (x + w > fb->width) {
        w = fb->width - x;
    }
    if (y + h > fb->height) {
        h = fb->height - y;
    }
    if (w <= 0 || h <= 0) {
        return;
    }
    for (int row = 0; row < h; row++) {
        uint16_t *p = fb->px + (size_t)(y + row) * (size_t)fb->width + (size_t)x;
        for (int col = 0; col < w; col++) {
            p[col] = color;
        }
    }
}

void fb_fill(fb_t *fb, uint16_t color)
{
    fb_rect(fb, 0, 0, fb->width, fb->height, color);
}

int fb_text(fb_t *fb, int x, int y, int scale, uint16_t color, const char *s)
{
    for (; *s; s++) {
        const glyph_t *g = find_glyph(*s);

        if (!g) {
            g = find_glyph('?');
        }
        for (int c = 0; c < 5; c++) {
            for (int r = 0; r < 7; r++) {
                if (g->col[c] & (1u << r)) {
                    fb_rect(fb, x + c * scale, y + r * scale, scale, scale, color);
                }
            }
        }
        x += 6 * scale;
    }
    return x;
}

int fb_text_width(int scale, size_t nchars)
{
    return nchars ? (int)(nchars * 6u * (size_t)scale) - scale : 0;
}
